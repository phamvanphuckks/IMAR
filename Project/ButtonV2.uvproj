# Keil uVision project ButtonV2.uvproj, settings and files
target Button (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ButtonV2 +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: .\inc;.\Library\Device\Include;.\Library\StdDriver\inc;..\Project
  group Startup
    ./: STARTUP.A51
  group src
    ./src/: gpio.c delay.c eeprom.c wdt.c uart.c ds1307.c timerx.c
  group inc
    ./inc/: app.h gpio.h hw_config.h delay.h eeprom.h uart.h ds1307.h timerx.h
  group app
    ./: main.c
    ./src/: app.c
    ./inc/: app.h
  group common
    ./Library/StdDriver/src/: sys.c
    ./src/: PUTCHAR.C
